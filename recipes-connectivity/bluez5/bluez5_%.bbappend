SRC_URI:remove:rpi = " \
    file://0004-Move-the-hciattach-firmware-into-lib-firmware.patch \
"

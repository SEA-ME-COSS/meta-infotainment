RDEPENDS:${PN} += " python3-setuptools"


# Due to compiling errors boost-python is disabled
PACKAGECONFIG ??= "locale"
